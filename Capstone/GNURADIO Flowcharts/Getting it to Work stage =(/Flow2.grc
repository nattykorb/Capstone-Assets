options:
  parameters:
    generate_options: qt_gui
    id: FM_DEMOD
    output_language: python
    title: FM_DEMOD
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '5'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '500.0'
    audio_stop: '25000.0'
    chan_rate: '192000'
    deviation: '1.0'
    gain: '1.0'
    tau: '1.0'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: Komplete Audio 6
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/nattykorb/Documents/GitHub/Capstone/SHEARS_LRG_snip_denoised.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '1'
    cutoff_freq: '500'
    gain: '1'
    interp: '1'
    samp_rate: '192000'
    type: interp_fir_filter_fff
    width: '3000'
    win: window.WIN_BLACKMAN
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '1'
    resamp_ratio: '0.25'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '10000'
    fc: '1500'
    fftsize: '1024'
    grid: 'True'
    name: DEMOD1
    type: float
    wintype: window.WIN_BLACKMAN
    ymax: '5'
    ymin: '-90'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: '1'
    ntaps: 11*samp_rate
    samp_rate: '192000'
    sym_rate: '1.0'
    type: interp_fir_filter_fff
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', hilbert_fc_0, '0']
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_fm_demod_cf_0, '0', mmse_resampler_xx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', high_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '0', high_pass_filter_0, '0']
- [high_pass_filter_0, '0', analog_agc_xx_0, '0']
- [hilbert_fc_0, '0', analog_fm_demod_cf_0, '0']
- [mmse_resampler_xx_0, '0', audio_sink_0, '0']
- [mmse_resampler_xx_0, '0', audio_sink_0, '1']
- [root_raised_cosine_filter_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
