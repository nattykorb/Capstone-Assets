options:
  parameters:
    generate_options: qt_gui
    id: FM_DEMOD
    output_language: python
    title: FM_DEMOD
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '1000.0'
    audio_stop: '25000.0'
    chan_rate: '192000'
    deviation: '75000.0'
    gain: '1.0'
    tau: '1500.0'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/nattykorb/Documents/GitHub/Capstone/SHEARS_LRG_snip_denoised.wav
    repeat: 'True'
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '1'
    cutoff_freq: '1000'
    gain: '1'
    interp: '1'
    samp_rate: '192000'
    type: interp_fir_filter_fff
    width: '3'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '10000'
    fc: '5000'
    fftsize: '1024'
    grid: 'True'
    name: DEMOD1
    type: float
    wintype: window.WIN_BLACKMAN
    ymax: '5'
    ymin: '-90'
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_fm_demod_cf_0, '0', fft_vxx_1, '0']
- [blocks_wavfile_source_0, '0', high_pass_filter_0, '0']
- [fft_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [high_pass_filter_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
