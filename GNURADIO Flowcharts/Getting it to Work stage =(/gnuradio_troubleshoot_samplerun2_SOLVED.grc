options:
  parameters:
    catch_exceptions: 'False'
    generate_options: qt_gui
    id: fmx_2
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: Mode_Switcher
  id: variable_qtgui_chooser
  parameters:
    label: Mode Switcher
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: real
    value: '0'
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 7, 1, 2
    label: Frequency
    min_len: '1'
    outputmsgname: value
    showports: 'False'
    start: '1.'
    step: '.1'
    stop: '10000.'
    value: '1500.'
    widget: slider
  states: {}
- name: level
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 3, 1, 2
    label: Level
    min_len: '1'
    outputmsgname: level
    showports: 'False'
    start: '0'
    step: '.01'
    stop: '1'
    value: '.1'
    widget: slider
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 30, 1, 1
    label: Mode
    labels: '[''Norm'', ''Cal'']'
    num_opts: '0'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 1
    label: Source
    label0: Tone
    label1: Audio
    labels: '[''Tone'', ''Audio'']'
    num_opts: '2'
    option0: '0'
    option1: '1'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: source_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: taps_up
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '7500'
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: vco_sens
  id: variable
  parameters:
    comment: |-
      =2*pi*Carrier Freq

      753982.2369 base
    value: '4712'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 22, 1, 2
    label: Volume
    min_len: '3'
    outputmsgname: vol
    showports: 'True'
    start: '.1'
    step: '.01'
    stop: '1'
    value: '.7'
    widget: slider
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '10000'
    audio_stop: '11000'
    chan_rate: '120000'
    deviation: '10000'
    gain: '1.0'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: level
    freq: '1000'
    offset: '1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: level
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: source_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '3'
    gain: '1'
    high_cutoff_freq: '30000'
    low_cutoff_freq: '1000'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blks2_selector_0
  id: blks2_selector
  parameters:
    input_index: source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: blks2_selector_1
  id: blks2_selector
  parameters:
    input_index: mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.from_float(freq)
    period: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: level*10
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {state: disabled}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    comment: mode
    enabled: 'True'
    input_index: mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: vco_sens
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/nattykorb/Documents/GitHub/Capstone/ASSETS/SHEARS_loudest partials selected_stretched_24-Bit_30kHz.wav
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    comment: hello world!
    file: /Users/nattykorb/Documents/GitHub/Capstone/ASSETS/SHEARS_lps_looped_16-Bit_32kHz.wav
    maxoutbuf: '30000000'
    repeat: 'True'
  states: {}
- name: freq
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 0,20,1,10
    label: Frequency
    max: '5000'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {state: disabled}
- name: level
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 0,10,1,10
    label: Level
    max: '1'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.1'
  states: {state: disabled}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '1'
    resamp_ratio: '2'
    type: float
  states: {state: disabled}
- name: mode
  id: variable_chooser
  parameters:
    choices: '[0,1]'
    grid_pos: 0,40,1,10
    label: Mode
    labels: '[''Norm'',''Cal'']'
    style: wx.RA_HORIZONTAL
    type: radio_buttons
    value: '0'
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: 24 bit 30 khz WAV
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    note: Tansmitter
  states: {state: disabled}
- name: note_10
  id: note
  parameters:
    note: WX GUI Slider
  states: {state: disabled}
- name: note_11
  id: note
  parameters:
    note: WX GUI Slider
  states: {state: disabled}
- name: note_12
  id: note
  parameters:
    note: WX GUI Chooser
  states: {state: disabled}
- name: note_13
  id: note
  parameters:
    note: Selector
  states: {state: disabled}
- name: note_14
  id: note
  parameters:
    note: WX GUI Scope Sink
  states: {state: disabled}
- name: note_15
  id: note
  parameters:
    note: WX GUI Scope Sink
  states: {state: disabled}
- name: note_16
  id: note
  parameters:
    note: WX GUI FFT Sink
  states: {state: disabled}
- name: note_2
  id: note
  parameters:
    note: Receiver
  states: {state: disabled}
- name: note_3
  id: note
  parameters:
    note: WX GUI Notebook
  states: {state: disabled}
- name: note_5
  id: note
  parameters:
    note: Selector
  states: {state: disabled}
- name: note_6
  id: note
  parameters:
    note: WX GUI Scope Sink
  states: {state: disabled}
- name: note_7
  id: note
  parameters:
    note: WX GUI FFT Sink
  states: {state: disabled}
- name: note_8
  id: note
  parameters:
    note: WX GUI Chooser
  states: {state: disabled}
- name: note_9
  id: note
  parameters:
    note: WX GUI Slider
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: '360000'
    comment: fm spectr
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@3
    name: FM Output Spectrum
    type: float
    update_time: '.1'
    ymax: '5'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '10000'
    comment: fm spectr
    fc: '5491'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@3
    name: FM Output Spectrum
    norm_window: 'True'
    tr_level: '1.0'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.0'
    ymax: '5'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '24000'
    fc: '0.'
    fftsize: '1024'
    gui_hint: tabs@4
    name: FM Demodulated
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.0'
    ymax: '10.'
    ymin: '-100.'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: '24000'
    fc: '0.'
    fftsize: '1024'
    gui_hint: tabs@4
    name: FM Demodulated
    type: float
    update_time: '0.0'
    ymax: '10.'
    ymin: '-100.'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '5441'
    fftsize: '1024'
    gui_hint: tabs@3
    name: FM Output Spectrum
    plotconst: 'False'
    plottime: 'False'
    rate: '.1'
    showrf: 'True'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: cyan
    ctrlpanel: 'True'
    gui_hint: tabs@0
    label1: Rendered Audio
    name: Rendered Audio
    size: '1024'
    srate: source_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    comment: freq
    gui_hint: tabs@2
    name: FM Signal
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    comment: freq
    gui_hint: tabs@2
    name: FM Signal
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@1
    name: Modulating Signal
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.0'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '15'
    taps: taps_up
    type: fff
  states: {state: disabled}
- name: source
  id: variable_chooser
  parameters:
    choices: '[0,1]'
    grid_pos: 0,0,1,10
    label: Source
    labels: '[''Tone'',''Audio'']'
    style: wx.RA_HORIZONTAL
    type: radio_buttons
    value: '0'
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Source
    label1: Message
    label2: FM Signal
    label3: FM Spectrum
    label4: DeMod
    num_tabs: '5'
  states: {}
- name: tabs
  id: notebook
  parameters:
    labels: '[''Source'', ''Message'', ''FM Signal'',''FM Spectrum'', ''Demod'']'
    style: wx.NB_TOP
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '101'
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '102'
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '101'
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: '102'
  states: {state: disabled}
- name: vol
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 0,30,1,10
    label: Volume
    max: '1'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '.2'
  states: {state: disabled}
- name: wxgui_fftsink2_0
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '2048'
    freqvar: None
    notebook: tabs,3
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: samp_rate
    title: FM Output Spectrum
    type: float
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}
- name: wxgui_fftsink2_1
  id: wxgui_fftsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: '0'
    fft_rate: '15'
    fft_size: '1024'
    freqvar: None
    notebook: tabs,4
    peak_hold: 'False'
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: '24000'
    title: FM Demodulated
    type: float
    win: None
    y_divs: '10'
    y_per_div: '10'
  states: {state: disabled}
- name: wxgui_scopesink2_0
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    notebook: tabs,0
    num_inputs: '1'
    samp_rate: source_rate
    t_scale: '0.005'
    title: Baseband Audio
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '0'
    v_scale: '0.5'
    xy_mode: 'False'
    y_axis_label: Amplitude
  states: {state: disabled}
- name: wxgui_scopesink2_1
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    notebook: tabs,1
    num_inputs: '1'
    samp_rate: samp_rate
    t_scale: '.01'
    title: Modulating Signal
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '1'
    v_scale: '.05'
    xy_mode: 'False'
    y_axis_label: Amplitude
  states: {state: disabled}
- name: wxgui_scopesink2_2
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    notebook: tabs,2
    num_inputs: '1'
    samp_rate: samp_rate
    t_scale: '.005'
    title: FM Signal
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '0'
    v_scale: '0.5'
    xy_mode: 'False'
    y_axis_label: Amplitude
  states: {state: disabled}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [band_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_selector_0_0, '1']
- [blocks_message_strobe_0, strobe, analog_sig_source_x_1, cmd]
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_freq_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_selector_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0_0, '0', blocks_vco_f_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '0']
- [blocks_vco_f_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vco_f_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', mmse_resampler_xx_0, '0']
- [blocks_wavfile_source_0, '0', mmse_resampler_xx_0, '1']
- [blocks_wavfile_source_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_0, '0']
- [virtual_source_2, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
