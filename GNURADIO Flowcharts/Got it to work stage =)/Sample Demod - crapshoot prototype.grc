options:
  parameters:
    catch_exceptions: 'False'
    generate_options: qt_gui
    id: fmx_2
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: audiocomp
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 25, 1, 1
    label: Audio Comparisons
    label0: WAV
    label1: DMed
    label2: DMed 2
    labels: '[''WAV'', ''DMed, DMed 2'']'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    options: '[0, 1, 2,]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: bphic
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 13, 1, 4
    label: BP Hi Cutoff
    min_len: '20'
    outputmsgname: value
    showports: 'False'
    start: bploc+1
    step: '1'
    stop: '25000'
    value: '15000'
  states: {}
- name: bploc
  id: variable_qtgui_range
  parameters:
    gui_hint: 3, 1, 1, 4
    label: BP Low Cutoff
    min_len: '1'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '10000'
    value: '1500'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 7, 1, 3
    label: Frequency
    min_len: '1'
    outputmsgname: value
    showports: 'False'
    start: '1.'
    step: '.001'
    stop: '10000.'
    value: '1500.'
  states: {}
- name: level
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 1, 1, 3
    label: Level
    min_len: '1'
    outputmsgname: level
    showports: 'False'
    start: '0'
    step: '.001'
    stop: '1'
    value: '.2'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 30, 1, 1
    label: Mode
    labels: '[''FMSig'', ''CalTone'']'
    num_opts: '0'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 1
    label: source
    labels: '[''Tone'', ''Audio'']'
    num_opts: '0'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: source_rate
  id: variable
  parameters:
    comment: match the input recording!
    value: '32000'
  states: {}
- name: transw
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,  8, 1, 4
    label: BP Transition Width
    min_len: '10'
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '3000'
    value: '250'
  states: {}
- name: vco_sens
  id: variable
  parameters:
    comment: |-
      =2*pi*Carrier Freq

      753982.2369 base
    value: '34501.8'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 12, 1, 3
    label: Volume
    min_len: '1'
    outputmsgname: vol
    showports: 'False'
    start: '.01'
    step: '.001'
    stop: '.3'
    value: '.15'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '5000'
    audio_stop: '11000'
    chan_rate: samp_rate
    deviation: '5000'
    gain: '1.0'
    tau: '0.0'
  states: {}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '5000'
    audio_stop: '11000'
    chan_rate: samp_rate
    deviation: '5000'
    gain: '1.0'
    tau: '0.0'
  states: {}
- name: analog_fm_demod_cf_0_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '5000'
    audio_stop: '11000'
    chan_rate: samp_rate
    deviation: '5000'
    gain: '1.0'
    tau: '0.0'
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: level
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '3'
    gain: '1'
    high_cutoff_freq: bphic
    low_cutoff_freq: bploc
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: transw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '3'
    gain: '1'
    high_cutoff_freq: bphic
    low_cutoff_freq: bploc
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: transw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '3'
    gain: '1'
    high_cutoff_freq: bphic
    low_cutoff_freq: bploc
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: transw
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: level*50
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    comment: mode
    enabled: 'True'
    input_index: mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audiocomp
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_vco_f_0_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: vco_sens
  states: {}
- name: blocks_vco_f_0_1
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: vco_sens
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/nattykorb/Documents/GitHub/Capstone/ASSETS/SHEARS_lps_looped_16-Bit_32kHz.wav
    repeat: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      -----------> and   II
                                  \/
    note: QT GUI Objects
  states: {}
- name: note_1
  id: note
  parameters:
    note: ADJUST ACCORDINGLY
  states: {}
- name: note_2
  id: note
  parameters:
    comment: Modulated v. Unmodulated Carrier Freq
    note: COMPARISON SWITCH
  states: {}
- name: note_3
  id: note
  parameters:
    note: DEMODULATION CIRCUIT
  states: {}
- name: note_3_0
  id: note
  parameters:
    note: AUDIO IN
  states: {}
- name: note_4
  id: note
  parameters:
    note: AUDIO OUT
  states: {}
- name: note_5
  id: note
  parameters:
    note: demodulated signal out
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '10000'
    comment: tab4
    fc: '5000'
    fftsize: '1024'
    gui_hint: tabs@4
    name: FM Demodulated
    plotconst: 'False'
    rate: '.01'
    showrf: 'True'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2
    name: 2nd Demod
    plotconst: 'False'
    plottime: 'False'
    rate: '.01'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: '10000'
    comment: tab3
    fc: '10000'
    fftsize: '1024'
    gui_hint: tabs@3
    name: FM Output Spectrum
    rate: '.001'
    type: float
  states: {}
- name: qtgui_sink_x_1_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark green
    comment: tab0
    ctrlpanel: 'True'
    gui_hint: tabs@0
    label1: Rendered Audio
    name: Sample Audio
    size: '1024'
    srate: source_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '15'
    taps: taps_up
    type: fff
  states: {state: bypassed}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Source
    label1: Message
    label2: FM DeMod2 (pr. FM Signal)
    label3: FM Spectrum
    label4: DeMod
    num_tabs: '5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: 3_dmed2
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: 1_raw
    stream_id: 1_raw
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    comment: 2_dmed
    stream_id: 2_dmed
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: 3_dmed2
    stream_id: 3_dmed2
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    comment: 1_raw
    stream_id: 1_raw
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    comment: 1_raw
    stream_id: 1_raw
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    comment: 1_raw
    stream_id: 1_raw
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: 3_dmed2
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    comment: 3_dmed2
    stream_id: 3_dmed2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: 2_dmed
    stream_id: 2_dmed
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    comment: 2_dmed
    stream_id: 2_dmed
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_fm_demod_cf_0_0, '0', virtual_sink_0, '0']
- [analog_fm_demod_cf_0_0_0, '0', qtgui_sink_x_1_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_vco_f_0_0, '0']
- [band_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [band_pass_filter_0_0, '0', analog_fm_demod_cf_0_0, '0']
- [band_pass_filter_0_0_0, '0', analog_fm_demod_cf_0_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_vco_f_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_2, '0']
- [blocks_selector_0_0_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_selector_1, '0', audio_sink_0, '0']
- [blocks_vco_f_0_0, '0', blocks_selector_0_0_0, '1']
- [blocks_vco_f_0_1, '0', blocks_selector_0_0_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_selector_1, '0']
- [virtual_source_0_1_0, '0', band_pass_filter_0, '0']
- [virtual_source_0_1_0_0, '0', rational_resampler_xxx_0_0, '0']
- [virtual_source_1, '0', qtgui_sink_x_1, '0']
- [virtual_source_1_0, '0', blocks_selector_1, '2']
- [virtual_source_2, '0', blocks_selector_1, '1']
- [virtual_source_2_0, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
