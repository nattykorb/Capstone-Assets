options:
  parameters:
    catch_exceptions: 'False'
    generate_options: qt_gui
    id: fmx_2
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 7, 1, 2
    label: Frequency
    min_len: '1'
    outputmsgname: value
    showports: 'False'
    start: '1.'
    step: '.001'
    stop: '5000.'
    value: '1500.'
  states: {}
- name: level
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 3, 1, 2
    label: Level
    min_len: '1'
    outputmsgname: level
    showports: 'False'
    start: '0'
    step: '.001'
    stop: '1'
    value: '.5'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 30, 1, 1
    label: Mode
    labels: '[''Norm'', ''Cal'']'
    num_opts: '0'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0, 0, 1, 1
    label: source
    labels: '[''Tone'', ''Audio'']'
    num_opts: '0'
    options: '[0, 1]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: source_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: taps_up
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '7500'
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: vco_sens
  id: variable
  parameters:
    comment: |-
      =2*pi*Carrier Freq

      753982.2369 base
    value: '341860'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 22, 1, 2
    label: Volume
    min_len: '1'
    outputmsgname: vol
    showports: 'True'
    start: '.01'
    step: '.001'
    stop: '.3'
    value: '.15'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '5000'
    audio_stop: '11000'
    chan_rate: samp_rate
    deviation: '5000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: level
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: level
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: source_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '3'
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '1000'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: level*50
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    comment: mode
    enabled: 'True'
    input_index: mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: vco_sens
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/nattykorb/Documents/GitHub/Capstone/ASSETS/SHEARS_lps_looped_16-Bit_32kHz.wav
    repeat: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 24 bit 30 khz WAV
  states: {}
- name: note_1
  id: note
  parameters:
    note: Tansmitter
  states: {}
- name: note_2
  id: note
  parameters:
    note: Receiver
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '13000'
    comment: tab4
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@4
    name: FM Demodulated
    plotconst: 'False'
    rate: '.01'
    showrf: 'True'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: tab3
    fc: freq
    fftsize: '1024'
    gui_hint: tabs@3
    name: FM Output Spectrum
    plotconst: 'False'
    plottime: 'False'
    rate: '.001'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: dark green
    comment: tab0
    ctrlpanel: 'True'
    gui_hint: tabs@0
    label1: Rendered Audio
    name: Rendered Audio
    size: '1024'
    srate: source_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    update_time: '0.001'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: black
    comment: tab2_freq
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tabs@2
    name: FM Signal
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.001'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    color1: dark blue
    comment: tab1
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tabs@1
    name: Modulating Signal
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    update_time: '0.1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '15'
    taps: taps_up
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Source
    label1: Message
    label2: FM Signal
    label3: FM Spectrum
    label4: DeMod
    num_tabs: '5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '101'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '102'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '101'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '101'
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: '102'
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [band_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_selector_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0, '0', virtual_sink_0, '0']
- [blocks_selector_0_0, '0', blocks_vco_f_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '0']
- [blocks_vco_f_0, '0', qtgui_sink_x_1, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vco_f_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_2, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
